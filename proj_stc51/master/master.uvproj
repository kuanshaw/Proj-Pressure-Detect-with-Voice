# Keil uVision project master.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: master +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\NRF24L01多节点接收
  group Source Group 1
    ./: NRF24L01.c DELAY.c MAX232.c LCD1602.c master_main.c
